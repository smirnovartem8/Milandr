# Keil uVision project usb_cdc_echo.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MDR1986VK01 Milandr
  pack: Keil.MDR1986VK01.1.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x2000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: usb_cdc_echo
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: FLASH __FPU_PRESENT = 1
  c include: ..\usb_cdc_echo
  memory RVCT4: ROM 0x2000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group usr
    ./: main.c MDR32F2C10_usb_CDC.c MDR32F2C10_usb_device.c systick.c
software components: CMSIS:CORE 5.4.0, Board Support:Board Setup 1.0, Device:ADC 1.0, Device:CONFIG 1.0, Device:DEMOBOARD 1.0, Device:Startup 1.0, Drivers:CLK 1.0, Drivers:DELAY 1.0, Drivers:PORT 1.0, Drivers:USB 1.0
