# Keil uVision project eth_loopback.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR32F8 Milandr
  pack: Keil.MDR1986VE8T.0.4
  cpu: IROM(0x20006000,0x2000) IRAM(0x20000000,0x6000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: eth_loopback
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x20004000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group user
    ./: main.c
software components: CMSIS:CORE 3.30.0, Board Support:Board Setup 1.0.1, Device:Startup 1.3.1, Drivers:CLKCTRL 1.3.1, Drivers:CONFIG 1.3.1, Drivers:DMA 1.3.1, Drivers:ETH 1.3.1, Drivers:LIB 1.3.1, Drivers:PORT 1.3.1
