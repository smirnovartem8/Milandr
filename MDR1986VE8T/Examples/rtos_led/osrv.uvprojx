# Keil uVision project osrv.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR32F8 Milandr
  pack: Keil.MDR1986VE8T.0.2
  cpu: IRAM(0x20000000,0x6000) IROM(0x20006000,0x2000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: osrv
  c flags: Optim=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x20004000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 5.1.2, CMSIS:RTOS2:Keil RTX5 5.4.0, Board Support:Board Setup 0.2, Device:Startup 0.2, Drivers:CLKCTRL 0.2, Drivers:CONFIG 0.2, Drivers:LIB 0.2, Drivers:PORT 0.2
