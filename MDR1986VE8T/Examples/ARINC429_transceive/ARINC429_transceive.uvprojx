# Keil uVision project ARINC429_transceive.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR32F8 Milandr
  pack: Keil.MDR1986VE8T.0.4
  cpu: IROM(0x20006000,0x2000) IRAM(0x20000000,0x6000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: ARINC429_transceive
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x20005000 size 0x3000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./: main.c
software components: CMSIS:CORE 5.2.0, Board Support:Board Setup 0.4, Device:Startup 0.4, Drivers:ARINC429_rx 0.4, Drivers:ARINC429_tx 0.4, Drivers:CLKCTRL 0.4, Drivers:CONFIG 0.4, Drivers:LIB 0.4, Drivers:PORT 0.4
